# IAR project air_cleaner.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3U STM8S103F3U
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: air_cleaner.hex
  ILINK.IlinkOutputFile: air_cleaner.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group App
    App/: interrupt.c main.c
  group User
    User/: beep.c button.c buzzer.c filter.c led.c motor.c status.c sys.c tim.c uart.c
